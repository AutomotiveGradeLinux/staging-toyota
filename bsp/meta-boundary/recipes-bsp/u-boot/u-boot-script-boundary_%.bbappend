FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=30503fd321432fc713238f582193b78e"
SRCREV = "62132ae8ca90f821ae23bad8a70dfe50e1eaa62c"
SRCBRANCH = "boundary-v2018.07"
PV = "v2018.07+git${SRCPV}"
COMPATIBLE_MACHINE = "(nitrogen6x|nitrogen6x-lite|nitrogen6sx|nitrogen7|nitrogen8m|nitrogen8mm|imx6-acl)"
